options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_transceiver
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "STA", "Linear Comb"]'
    num_opts: '0'
    options: '[ieee802_11.LS, ieee802_11.LMS, ieee802_11.STA, ieee802_11.COMB]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: delay_tx2rx
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '37'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '2801'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 914e6
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: pad_front+pad_tail+640+frame_len
  states: {}
- name: pad_front
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: pad_tail
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: usrp_sink_addr
  id: variable
  parameters:
    value: '"addr0=192.168.30.2, addr1=192.168.30.1"'
  states: {}
- name: usrp_source_addr
  id: variable
  parameters:
    value: '"addr0=192.168.30.2, addr1=192.168.30.1"'
  states: {}
- name: variable_function_probe_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(1.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_1
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(1.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_1_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_2
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wimnet-sdrdev/Desktop/radio_files/wifi_tx_bpsk34_radio2
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/wimnet-sdrdev/Desktop/radio_files/wifi_tx_bpsk34_radio1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("NONE")
    period: '10000000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("NONE")
    period: '10000000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_len
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_len
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: out_buf_size
    packet_len: packet_len
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: out_buf_size
    packet_len: packet_len
    type: complex
  states: {}
- name: fullduplex_digital_sic_0
  id: fullduplex_digital_sic
  parameters:
    debug: 'False'
    delay_tx2rx: delay_tx2rx
    frame_len: 'frame_len + 640 + frame_len '
    minoutbuf: out_buf_size
    pad_front: pad_front
    premultiplier: '1'
    si_chan_dim: '1'
    si_chan_k: '10'
    sig_pilot_pos: '0'
  states: {}
- name: fullduplex_digital_sic_0_0
  id: fullduplex_digital_sic
  parameters:
    debug: 'False'
    delay_tx2rx: delay_tx2rx
    frame_len: 'frame_len + 640 + frame_len '
    minoutbuf: out_buf_size
    pad_front: pad_front
    premultiplier: '1'
    si_chan_dim: '1'
    si_chan_k: '10'
    sig_pilot_pos: '1'
  states: {}
- name: fullduplex_packet_encap2_0
  id: fullduplex_packet_encap2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '1'
    minoutbuf: out_buf_size
    pad_front: pad_front
    pad_tail: pad_tail
    premultiplier: 0.3*0.5
    sig_pilot_pos: '1'
    sync_word: '0'
  states: {}
- name: fullduplex_packet_encap2_0_0
  id: fullduplex_packet_encap2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '1'
    minoutbuf: out_buf_size
    pad_front: pad_front
    pad_tail: pad_tail
    premultiplier: 0.3*0.5
    sig_pilot_pos: '0'
    sync_word: '0'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: ieee802_11_mac_0_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
    radio: '1'
    to_file: 'True'
  states: {}
- name: ieee802_11_parse_mac_0_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
    radio: '2'
    to_file: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: out0 is radio 2
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: in0 is radio 2
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: '"SI after Circ. + RF Canc. - I"'
    label2: '"SI after Circ. + RF Canc. - Q"'
    label3: '"SI after Circ. + RF Canc. + Digital Canc. - I"'
    label4: '"SI after Circ. + RF Canc. + Digital Canc. - Q"'
    name: Scope Plot
    nconnections: '2'
    size: 'frame_len + 640 + frame_len '
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: '0.50'
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@2
    label1: '"Digital Canc. Tap - I"'
    label2: '"Digital Canc. Tap - Q"'
    marker1: '0'
    marker2: '0'
    size: 21 * 1
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Rx Packets
    label1: Rx Signal Spectr
    label2: Estimated Digital Taps
    label3: SI Channel
    num_tabs: '4'
  states: {state: disabled}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    clock_source1: mimo
    dev_addr: usrp_sink_addr
    dev_args: '""'
    gain0: '10'
    gain1: '10'
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: pc_clock
    time_source1: mimo
    type: fc32
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    clock_source1: mimo
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_addr: usrp_source_addr
    dev_args: '""'
    gain0: '10'
    gain1: '10'
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: pc_clock
    time_source1: mimo
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_stream0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tx_stream1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx_stream0
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: tx_stream1
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: chan_est
    encoding: encoding
    frequency: freq
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: chan_est
    encoding: encoding
    frequency: freq
    sensitivity: '0.56'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_message_strobe_0, strobe, ieee802_11_mac_0, app in]
- [blocks_message_strobe_0_0, strobe, ieee802_11_mac_0_0, app in]
- [blocks_multiply_const_vxx_0, '0', fullduplex_packet_encap2_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', fullduplex_packet_encap2_0_0, '0']
- [blocks_null_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', fullduplex_digital_sic_0, '1']
- [blocks_stream_to_tagged_stream_1_0, '0', fullduplex_digital_sic_0_0, '1']
- [fullduplex_digital_sic_0, '0', blocks_null_sink_1_0_0_0_0, '0']
- [fullduplex_digital_sic_0, '1', wifi_phy_hier_0, '0']
- [fullduplex_digital_sic_0, '2', blocks_null_sink_1_0_0, '0']
- [fullduplex_digital_sic_0, '2', qtgui_time_sink_x_1, '0']
- [fullduplex_digital_sic_0_0, '0', blocks_null_sink_1_0_0_0_1, '0']
- [fullduplex_digital_sic_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fullduplex_digital_sic_0_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [fullduplex_digital_sic_0_0, '1', wifi_phy_hier_0_0, '0']
- [fullduplex_digital_sic_0_0, '2', blocks_null_sink_1_0_0_0, '0']
- [fullduplex_packet_encap2_0, '0', uhd_usrp_sink, '0']
- [fullduplex_packet_encap2_0, '0', virtual_sink_0_0, '0']
- [fullduplex_packet_encap2_0_0, '0', uhd_usrp_sink, '1']
- [fullduplex_packet_encap2_0_0, '0', virtual_sink_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [ieee802_11_mac_0_0, phy out, wifi_phy_hier_0_0, mac_in]
- [uhd_usrp_source, '0', blocks_stream_to_tagged_stream_1_0, '0']
- [uhd_usrp_source, '1', blocks_stream_to_tagged_stream_1, '0']
- [virtual_source_0_0, '0', fullduplex_digital_sic_0, '0']
- [virtual_source_0_0_0, '0', fullduplex_digital_sic_0_0, '0']
- [wifi_phy_hier_0, '0', blocks_null_sink_0_0, '0']
- [wifi_phy_hier_0, mac_out, ieee802_11_parse_mac_0, in]
- [wifi_phy_hier_0_0, '0', blocks_null_sink_0_0_0, '0']
- [wifi_phy_hier_0_0, mac_out, ieee802_11_parse_mac_0_0, in]

metadata:
  file_format: 1
