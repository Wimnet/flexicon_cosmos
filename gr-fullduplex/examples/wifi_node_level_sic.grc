options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_transceiver
    output_language: python
  states: {}

blocks:
- name: att_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '127'
    value: '127'
  states: {}
- name: att_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '127'
    value: '127'
  states: {}
- name: att_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '127'
    value: '0'
  states: {}
- name: canc_path
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,3
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: cap_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '6'
  states: {}
- name: cap_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '9'
  states: {}
- name: cap_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: cf_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '14'
  states: {}
- name: cf_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "STA", "Linear Comb"]'
    num_opts: '0'
    options: '[ieee802_11.LS, ieee802_11.LMS, ieee802_11.STA, ieee802_11.COMB]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: dac_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '165'
  states: {}
- name: dac_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '195'
  states: {}
- name: dac_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '0'
  states: {}
- name: delay_tx2rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,3
    orient: Qt.Horizontal
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {state: disabled}
- name: frame_len
  id: variable
  parameters:
    value: '1601'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 914e6
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: pad_front+pad_tail+640+frame_len
  states: {}
- name: pad_front
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: pad_tail
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: qf_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '31'
    value: '2'
  states: {}
- name: qf_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '31'
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: sub20_sn
  id: variable
  parameters:
    value: '"552C"'
  states: {}
- name: usrp_sink_addr
  id: variable
  parameters:
    value: '"addr0=192.168.30.2"'
  states: {}
- name: usrp_source_addr
  id: variable
  parameters:
    value: '"addr0=192.168.30.2"'
  states: {}
- name: variable_function_probe_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(1.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_1
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(1.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_1_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_2
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wimnet-sdrdev/Desktop/wifi_samples_tx_qpsk34_radio2
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '19.95262314968879601352'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '19.95262314968879601352'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1601'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: out_buf_size
    packet_len: packet_len
    type: complex
  states: {}
- name: fullduplex_digital_sic_0
  id: fullduplex_digital_sic
  parameters:
    alias: '96000'
    debug: 'False'
    delay_tx2rx: delay_tx2rx
    frame_len: frame_len + 640
    minoutbuf: out_buf_size
    pad_front: pad_front
    premultiplier: '1'
    si_chan_dim: '1'
    si_chan_k: '10'
    sig_pilot_pos: '0'
  states: {}
- name: fullduplex_fde_config_0
  id: fullduplex_fde_config
  parameters:
    att_0_val: att_0
    att_1_val: att_1
    att_2_val: att_2
    canc_path_val: canc_path
    cf_0_val: cf_0
    cf_1_val: cf_1
    dac_0_val: dac_0
    dac_1_val: dac_1
    dac_2_val: dac_2
    init_cap_addr: '0'
    init_cap_val: '0'
    qf_0_val: qf_0
    qf_1_val: qf_1
    sn_val: sub20_sn
    tuner_cap_0_val: cap_0
    tuner_cap_1_val: cap_1
    tuner_cap_2_val: cap_2
  states: {}
- name: fullduplex_packet_encap2_0
  id: fullduplex_packet_encap2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '1'
    minoutbuf: out_buf_size
    pad_front: pad_front
    pad_tail: pad_tail
    premultiplier: 0.3*0.5
    sig_pilot_pos: '0'
    sync_word: '0'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    label1: '"SI after Circ. + RF Canc."'
    label2: '"SI after Circ. + RF + Digital Canc."'
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.50'
    width1: '2'
    width2: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: packet_len
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: tab@0
    label1: '"SI after Circ. + RF Canc. - I"'
    label2: '"SI after Circ. + RF Canc. - Q"'
    label3: '"SI after Circ. + RF Canc. + Digital Canc. - I"'
    label4: '"SI after Circ. + RF Canc. + Digital Canc. - Q"'
    name: Scope Plot
    nconnections: '2'
    size: frame_len + 640
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: '0.50'
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@2
    label1: '"Digital Canc. Tap - I"'
    label2: '"Digital Canc. Tap - Q"'
    marker1: '0'
    marker2: '0'
    size: 21 * 1
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,3
    label0: Rx Packets
    label1: Rx Signal Spectr
    label2: Estimated Digital Taps
    label3: SI Channel
    num_tabs: '4'
  states: {}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    alias: usrp_sink
    ant0: TX/RX
    bw0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: usrp_sink_addr
    dev_args: '""'
    gain0: '10'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_addr: usrp_source_addr
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_stream0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx_stream0
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', fullduplex_packet_encap2_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_2_0, '0', qtgui_freq_sink_x_1, '1']
- [blocks_stream_to_tagged_stream_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', fullduplex_digital_sic_0, '1']
- [fullduplex_digital_sic_0, '0', blocks_multiply_const_vxx_2, '0']
- [fullduplex_digital_sic_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fullduplex_digital_sic_0, '1', blocks_multiply_const_vxx_2_0, '0']
- [fullduplex_digital_sic_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [fullduplex_digital_sic_0, '2', qtgui_time_sink_x_1, '0']
- [fullduplex_packet_encap2_0, '0', qtgui_time_sink_x_0, '0']
- [fullduplex_packet_encap2_0, '0', uhd_usrp_sink, '0']
- [fullduplex_packet_encap2_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_tagged_stream_1, '0']
- [virtual_source_0_0, '0', fullduplex_digital_sic_0, '0']

metadata:
  file_format: 1
